# Repository alan1998/YAWC

## KiCad design YAWC_Breath/Breath_Amp.kicad_pcb

Parts:
BITE1: CONN_01X02; Pin_Header_Angled_1x02
C1: 2n; R_0805_HandSoldering
C2: 1u; C_1206
C3: 820n; R_0805_HandSoldering
C4: 82n; R_0805_HandSoldering
P1: J_IO; Pin_Header_Angled_1x04
R1, R2: 10k; R_0805_HandSoldering
R3, R4: 150k; R_0805_HandSoldering
R5: 316; R_0805_HandSoldering
R6: 3600; R_0805_HandSoldering
R7: 100; R_0805_HandSoldering
RV1: 100k; TSM4YL
U1: MCP6002; SOIC-8-N
U2: MPX12DP; MPX1351-01

Connections:
/Bout: C3.1, P1.3, U1.6 (_), U1.7
/Pout: BITE1.2, P1.4, R7.2
/VCC: C2.1, P1.2, R7.1, RV1.1, U1.8 (V+), U2.3 (Vcc), U2.7
GND: BITE1.1, C2.2, C4.2, P1.1, R3.2, RV1.3, U1.4 (V-), U2.1 (GND), U2.5
unnamed: C1.1, R4.1, R5.2, U1.1
unnamed: C1.2, R1.1, R4.2, RV1.2, U1.2 (_)
unnamed: C3.2, R5.1, R6.2
unnamed: C4.1, R6.1, U1.5 (+)
unnamed: R1.2, U2.4 (-), U2.8
unnamed: R2.1, R3.1, U1.3 (+)
unnamed: R2.2, U2.2 (+), U2.6

Notes on the sheet:
Decouple

Board: 2 copper layers, 41.0 x 29.0 mm, 16 parts (1 on the bottom side), 11 nets.

## KiCad design YAWC_Keys/YAWC_Keys.kicad_pcb

Parts:
P1: K1; RndKeyCon5
P2: K2; RndKeyCon5
P3: K3; RndKeyCon5
P4: K4; TabKey3_5
P5: K5; TabKey3_5
P6: K6; RndKeyCon5
P7: K7; RndKeyCon5
P8: K8; RndKeyCon5
P9: K9; TabKey3_5
P10: K10; TabKey3_5
P11: K11; TabKey3_5
P12: CONN_01X04; Pin_Header_Angled_1x04
P13: CONN_01X04; Pin_Header_Straight_1x04
PLh1: CONN_01X05; Pin_Header_Straight_1x05
PRh1: CONN_01X06; Pin_Header_Straight_1x06
PTh1: CONN_01X05; Pin_Header_Angled_1x05
T1: T1; ThumbPad
T2: T2; ThumbPad
T3: T3; ThumbPad
T4: T4; ThumbPad
T5: T5; ThumbPad

Connections:
/+ve: P12.3, P13.2
/Bite: P12.1, P13.4
/Breath: P12.2, P13.3
/Gnd: P12.4, P13.1
unnamed: P1.1, PLh1.1
unnamed: P2.1, PLh1.2
unnamed: P3.1, PLh1.3
unnamed: P4.1, PLh1.4
unnamed: P5.1, PLh1.5
unnamed: P6.1, PRh1.1
unnamed: P7.1, PRh1.2
unnamed: P8.1, PRh1.3
unnamed: P9.1, PRh1.4
unnamed: P10.1, PRh1.5
unnamed: P11.1, PRh1.6
unnamed: PTh1.1, T5.1
unnamed: PTh1.2, T4.1
unnamed: PTh1.3, T3.1
unnamed: PTh1.4, T2.1
unnamed: PTh1.5, T1.1

Notes on the sheet:
Left Hand
Thumb
Right Hand

Board: 2 copper layers, 99.0 x 97.0 mm, 21 parts (1 on the bottom side), 20 nets.

## KiCad design YAWC_Cir/YAWC.kicad_pcb

Board: 2 copper layers, 84.0 x 34.0 mm, 32 parts (6 on the bottom side), 39 nets.

Parts:
ATP: CONN_1; Pin_Header_Straight_1x01
All Off: J_AllOff; B2B-XH
Amp1: CONN_4; Pin_Header_Straight_1x04
C1: 1u; C_1206_HandSoldering
C2: 4u7; C_1206_HandSoldering
C3, C4, C5, C6, C7: 100n; C_0603_HandSoldering
D1, D2: LED; LED-3MM
J_SWD1: ARM_SWD; 2x5_50mil_SMD
Midi: CONN_2; S2B-XH
P2: TP1a; Pin_Header_Straight_1x01
P3: CONN_5; Pin_Header_Straight_1x05
P4: CONN_5; S5B-XH
P5: CONN_6; Pin_Header_Straight_1x06
P6: TP1b; Pin_Header_Straight_1x01
Pot: J_Pot; B3B-XH
Pwr: CONN_01X03; S3B-XH
R1: 100k; R_0805_HandSoldering
R2, R4: R; R_0805_HandSoldering
R3: 10k; R_0805_HandSoldering
R5: 350; R_0805_HandSoldering
R6: 4k; R_0805_HandSoldering
R7: 1k; R_0805_HandSoldering
Rst: J_Reset; B2B-XH
SER1: CONN_3X2; Pin_Header_Angled_2x03
U1: TPS769XX; SOT-23-5
U2: SAMD20J18A-M; TQFP_64

Connections:
/Micro/Pot: Pot.2, U2.20
/Micro/Reset: J_SWD1.10, R1.2, Rst.2, U2.52
/Micro/S1P0: SER1.2, U2.35
/Micro/S1P1: SER1.1, U2.36
/Micro/S1P2: SER1.4, U2.37
/Micro/S1P3: SER1.3, U2.38
/Micro/SWCLK: J_SWD1.4, U2.57
/Micro/SWDIO: J_SWD1.2, U2.58
/Micro/Tx: R4.2, U2.29
/Micro/Y0: P5.5, U2.3
/Micro/Y1: P5.6, U2.4
/Micro/Y2: P3.2, U2.13
/Micro/Y3: P3.3, U2.14
/Micro/Y4: P3.4, U2.15
/Micro/Y5: P3.5, U2.16
/Micro/Y6: P5.1, U2.61
/Micro/Y7: P5.2, U2.62
/Micro/Y8: P5.3, U2.63
/Micro/Y9: P5.4, U2.64
/Micro/Y10: P4.1, U2.5
/Micro/Y11: P4.2, U2.6
/Micro/Y12: P4.3, U2.9
/Micro/Y13: P4.4, U2.10
/Micro/Y14: P4.5, U2.11
/Micro/Y15: P3.1, U2.12
/VBatt: C1.1, Pwr.3, R6.1, U1.1
BatSample: ATP.1, R6.2, R7.1, U2.19
Bth: Amp1.3, U2.17
GND: All Off.2, Amp1.1, C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, J_SWD1.3, J_SWD1.5, J_SWD1.9, P2.1, P6.1, Pot.3, Pwr.1, R7.2, Rst.1, SER1.5, U1.2, U1.3, U2.7, U2.22, U2.33, U2.47, U2.54
unnamed: C7.1, U2.55
unnamed: D1.1, U2.43
unnamed: D1.2, R5.1
unnamed: D2.1, U2.41
unnamed: D2.2, R2.1
unnamed: Midi.1, R4.1
unnamed: All Off.1, U2.24
unnamed: Pot.1, R3.2
VCC: Amp1.2, C2.1, C3.1, C4.1, C5.1, C6.1, J_SWD1.1, Midi.2, Pwr.2, R1.1, R2.2, R3.1, R5.2, SER1.6, U1.5, U2.8, U2.21, U2.34, U2.48, U2.56
Vib: Amp1.4, U2.18

## KiCad design YAWC_Cir/YAWC_v1.kicad_pcb

Board: 2 copper layers, 65.0 x 36.4 mm, 31 parts (8 on the bottom side), 41 nets.

Parts:
 : SolderWirePad_single_2mmDrill
A16, A17: CONN_1; Pin_Header_Straight_1x01
Amp: CONN_4; Pin_Header_Angled_1x04
C1: 1u; c_1206
C2: 4u7; c_1206
C3, C4, C5, C6, C7: 100n; c_0603
D1: LED; LED-1206
Midi: CONN_2; Pin_Header_Angled_1x02
P1: JST-PH_2; Pin_Header_Angled_1x02
P3, P4: CONN_5; Pin_Header_Angled_1x05
P5: CONN_6; Pin_Header_Angled_1x06
PB: Btns; Pin_Header_Straight_2x03
R1: 100k; Resistor_SMD0805_HandSoldering
R2, R3: 4k7; Resistor_SMD0805_HandSoldering
R4: R; Resistor_SMD0805_HandSoldering
R5: 350; Resistor_SMD0805_HandSoldering
R6: 4k; Resistor_SMD0805_HandSoldering
R7: 1k; Resistor_SMD0805_HandSoldering
Rst: CONN_2; Pin_Header_Angled_1x02
SER1: CONN_3X2; Pin_Header_Angled_2x03
SWD: CONN_5; Pin_Header_Straight_1x05
U1: TPS769XX; SOT23-5
U2: SAMD20J18A-M; TQFP_64
U3: MMA845Q; QFN16

Connections:
/Micro/PB11: PB.2, U2.24
/Micro/PB12: PB.4, U2.25
/Micro/PB13: PB.6, U2.26
/Micro/PB14: PB.3, U2.27
/Micro/Reset: R1.2, Rst.1, SWD.1, U2.52
/Micro/S1P0: SER1.4, U2.35
/Micro/S1P1: SER1.3, U2.36
/Micro/S1P2: SER1.2, U2.37
/Micro/S1P3: SER1.1, U2.38
/Micro/SWCLK: SWD.3, U2.57
/Micro/SWDIO: SWD.2, U2.58
/Micro/Tx: R4.2, U2.29
/Micro/Y0: P5.5, U2.3
/Micro/Y1: P5.6, U2.4
/Micro/Y2: P4.2, U2.13
/Micro/Y3: P4.3, U2.14
/Micro/Y4: P4.4, U2.15
/Micro/Y5: P4.5, U2.16
/Micro/Y6: P5.1, U2.61
/Micro/Y7: P5.2, U2.62
/Micro/Y8: P5.3, U2.63
/Micro/Y9: P5.4, U2.64
/Micro/Y10: P3.5, U2.5
/Micro/Y11: P3.4, U2.6
/Micro/Y12: P3.3, U2.9
/Micro/Y13: P3.2, U2.10
/Micro/Y14: P3.1, U2.11
/Micro/Y15: P4.1, U2.12
/Vbatt: C1.1, P1.1, R6.1, U1.1
BatSample: A17.1, R6.2, R7.1, U2.18
Bth: Amp.3, U2.20
GND: Amp.1, C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, Midi.2, P1.2, PB.1, PB.5, R7.2, Rst.2, SER1.5, SWD.5, U1.2, U1.3, U2.7, U2.22, U2.33, U2.47, U2.54, U3.5, U3.7, U3.10, U3.12
unnamed: A16.1, U2.17
unnamed: C7.1, U2.55
unnamed: D1.1, R5.1
unnamed: D1.2, U2.59
unnamed: Midi.1, R4.1
SCL: R3.2, U2.44, U3.4
SDA: R2.2, U2.43, U3.6
VCC: Amp.2, C2.1, C3.1, C4.1, C5.1, C6.1, R1.1, R2.1, R3.1, R5.2, SER1.6, SWD.4, U1.5, U2.8, U2.21, U2.34, U2.48, U2.56, U3.1, U3.14
Vib: Amp.4, U2.19

## Commit log

2014-06-13 Initial add
2014-06-13 Stuff
2014-06-13 Add some more footprints
2014-06-13 Update pad sizes
2014-06-15 Buttons. Need to DRC
2014-06-16 Pin header library
2014-06-16 More updates. Foot prints still to check
2014-06-18 Route not finished. Components done
2014-06-18 More
2014-06-19 All routed and DRC No gnd fill No silk screen detail done
2014-06-19 Board resized
2014-06-19 Mount holes
2014-06-19 Added fill Still need silk screen
2014-06-20 Silk screen finished. Although missed polarisation off power
2014-06-20 Gerb zip as sent to OSH
2016-02-16 Add Keys project
2016-02-16 Lib updates
2016-02-22 Schematic for version with finger boards done. Parts matched.
2016-03-02 More added and PCB layout of main board moved on a bit
2016-03-02 Possition centre lines and connectors
2016-03-03 Correct center lines again
2016-03-21 Add route plugs for breath amp through to main board via keys. Add straight 1x6 header
2016-03-21 More work on main PCB and positioned connectors to match Keys
2016-03-22 move parts nearer final positions
2016-03-28 Routed but no copper pour
2016-03-29 As subbmitted to OSH Park
2016-03-29 As sent to Seeed
2016-04-11 Positioned connector and unrouted old
2016-04-12 Routed. DRC'd. Not gerber viewed
2016-04-12 As sent to OSH park
